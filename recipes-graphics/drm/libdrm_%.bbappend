PACKAGECONFIG = "libkms install-test-programs"