# Remove timesyncd (not used - slows reboot)
PACKAGECONFIG:remove = "timesyncd"